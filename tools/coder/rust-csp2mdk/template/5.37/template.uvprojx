# Keil uVision project template.uvprojx, settings and files
target  (ARM-ADS)
  output: +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
software components: CMSIS:CORE 4.3.0
